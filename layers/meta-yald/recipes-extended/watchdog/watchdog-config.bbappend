FILESEXTRAPATHS:prepend := "${THISDIR}/watchdog-config:"
