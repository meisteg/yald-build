FILESEXTRAPATHS:prepend := "${THISDIR}/util-linux:"

SRC_URI += "file://0003-agetty-fix-stdin-conversion-to-tty-name.patch"
