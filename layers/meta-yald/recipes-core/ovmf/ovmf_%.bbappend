FILESEXTRAPATHS:prepend := "${THISDIR}/ovmf:"

PV = "edk2-stable202502"
SRCREV = "fbe0805b2091393406952e84724188f8c1941837"
