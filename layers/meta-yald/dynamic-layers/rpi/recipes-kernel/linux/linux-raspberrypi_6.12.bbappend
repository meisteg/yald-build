# Clear out PE to normalize kernel version
PE = ""
