FILESEXTRAPATHS:prepend := "${THISDIR}/pkgconfig:"

SRC_URI += "file://0001-Do-not-use-bool-as-a-field-name.patch"
